# Keil uVision project STM32F4_PocketMachin.uvprojx, settings and files
target STM32F4_PocketMachin (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F4_PocketMachin +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middleware/Library;../Middleware/Device;../Middleware/App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middleware/Library
    ../Middleware/Library/MALLOC/: malloc.c
    ../Middleware/Library/list/: list.c list_iterator.c list_node.c
    ../Middleware/Library/SmartTimer/: smarttimer.c
    ../Middleware/Library/letter-shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_cfg.h
    ../Middleware/Library/FlexibleButton/: flexible_button.c
    ../Middleware/Library/libdgus_ii/: dgus_control_curve.c dgus_control_text.c dgus_lcd.c dgus_util.c
    ../Middleware/Library/lwrb/: lwrb.c
  group Middleware/Device
    ../Middleware/Device/led/: led.c
    ../Middleware/Device/beep/: beep.c
    ../Middleware/Device/touchkey/: touchkey.c
    ../Middleware/Device/matrixkey/: matrixkey.c
    ../Middleware/Device/tftlcd/: fonts.c st7789.c
    ../Middleware/Device/diwenlcd/: dewenlcd.c
    ../Middleware/Device/voice/: voice.c
    ../Middleware/Device/tirpod/: relay.c stepmotor.c tirpod.c
    ../Middleware/Device/vision/: vision.c
  group Middleware/App
    ../Middleware/App/: app.c _Debug.c
software components: CMSIS:CORE 4.3.0
